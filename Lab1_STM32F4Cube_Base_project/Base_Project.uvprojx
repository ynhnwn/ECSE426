# Keil uVision project Base_Project.uvprojx, settings and files
target Lab 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base_Project
  c flags: Optim=1 wLevel=2
  c define: HSE_VALUE=8000000, STM32F407xx, ARM_MATH_CM4, __FPU_PRESENT = 1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Sources
    ./Sources/: main.c fput_debug.c Assembly.s
    ./: Kalmanfilter_test.s setupkalman.s kalman_filter.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 2.4.2
